* C:\tmp\_NextStepRC\MegaCore 2560 Shield\Mega_2560 core mini_full_2.0_PM\Mega_2560 core mini_full_2.0.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 13/10/2017 14:03:14

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
* Sheet Name: /OpenAVRc_Sticks/
C9  /OpenAVRc_Sticks/Stick_LVcon GND 100nF
C11  /OpenAVRc_Sticks/Stick_LHcon GND 100nF
C16  /OpenAVRc_Sticks/Stick_RHcon GND 100nF
C17  /OpenAVRc_Sticks/Stick_RVcon GND 100nF
U6  Stick_RH Net-_C43-Pad2_ Net-_C42-Pad1_ VCC Net-_C42-Pad1_ Net-_C44-Pad2_ Stick_RV Stick_LV Net-_C45-Pad2_ Net-_C42-Pad1_ GND Net-_C42-Pad1_ Net-_C46-Pad2_ Stick_LH MCP604-I/SL
R26  Net-_C43-Pad2_ /OpenAVRc_Sticks/Stick_RHcon 47K
R28  Net-_C43-Pad2_ Net-_R28-Pad2_ 120K
C43  Stick_RH Net-_C43-Pad2_ 22nF
C44  Stick_RV Net-_C44-Pad2_ 22nF
RV2  GND Net-_R28-Pad2_ VCC 100K
R29  Net-_C44-Pad2_ /OpenAVRc_Sticks/Stick_RVcon 47K
R31  Net-_C44-Pad2_ Net-_R31-Pad2_ 120K
RV3  GND Net-_R31-Pad2_ VCC 100K
C45  Stick_LV Net-_C45-Pad2_ 22nF
R32  Net-_C45-Pad2_ /OpenAVRc_Sticks/Stick_LVcon 47K
R34  Net-_C45-Pad2_ Net-_R34-Pad2_ 120K
RV4  GND Net-_R34-Pad2_ VCC 100K
C46  Stick_LH Net-_C46-Pad2_ 22nF
R35  Net-_C46-Pad2_ /OpenAVRc_Sticks/Stick_LHcon 47K
R37  Net-_C46-Pad2_ Net-_R37-Pad2_ 120K
RV5  GND Net-_R37-Pad2_ VCC 100K
R24  VCC Net-_C42-Pad1_ 82K
C42  Net-_C42-Pad1_ GND 6.8nF
R25  Net-_C42-Pad1_ GND 39K
W1  Stick_RH /OpenAVRc_Sticks/Stick_RHcon TEST_2P
W2  Stick_RV /OpenAVRc_Sticks/Stick_RVcon TEST_2P
W3  Stick_LV /OpenAVRc_Sticks/Stick_LVcon TEST_2P
W4  Stick_LH /OpenAVRc_Sticks/Stick_LHcon TEST_2P
R27  Net-_R11-Pad1_ Stick_RH Stick_RH 100K
R11  Net-_R11-Pad1_ Net-_C43-Pad2_ 120K
R30  Net-_R12-Pad1_ Stick_RV Stick_RV 100K
R12  Net-_R12-Pad1_ Net-_C44-Pad2_ 120K
R33  Net-_R13-Pad1_ Stick_LV Stick_LV 100K
R36  Net-_R14-Pad1_ Stick_LH Stick_LH 100K
R13  Net-_R13-Pad1_ Net-_C45-Pad2_ 120K
R14  Net-_R14-Pad1_ Net-_C46-Pad2_ 120K
C4  VCC GND 100nF
P28  VCC /OpenAVRc_Sticks/Power_manches +3.3V 5v/3,3v manches
P13  /OpenAVRc_Sticks/Power_manches /OpenAVRc_Sticks/Power_manches /OpenAVRc_Sticks/Stick_RHcon /OpenAVRc_Sticks/Stick_RVcon GND GND Stick_right
P12  /OpenAVRc_Sticks/Power_manches /OpenAVRc_Sticks/Power_manches /OpenAVRc_Sticks/Stick_LVcon /OpenAVRc_Sticks/Stick_LHcon GND GND Stick_left
C12  Pot_3 GND 100nF
C13  Pot_2 GND 100nF
C14  Pot_1 GND 100nF
P32  VCC Pot_1 GND Pot1
P31  VCC Pot_2 GND Pot2
P4  VCC Pot_3 GND Pot3
P14  Sw_id1 Sw_id2 Sw_rudDR Sw_gear Sw_ailDR Sw_thcut Sw_eleDR Sw_turn GND GND Switch
P11  Trim_LH-> Trim_LH<- Trim_RV<- Trim_LV<- Trim_RH-> Trim_RH<- Trim_LV-> Trim_RV-> GND GND Trim
C29  Rot_1A GND 100nF
C27  Rot_1B GND 100nF
C26  Rot_1push GND 100nF
C34  Rot_2A GND 100nF
C33  Rot_2B GND 100nF
C32  Rot_2push GND 100nF
P23  Rot_1push Rot_1B Rot_1A GND Rot_1
P24  Rot_2push Rot_2B Rot_2A GND Rot_2
R19  VCC Rot_1push 5.1k
R18  VCC Rot_1B 5.1k
R23  VCC Rot_2push 5.1k
R22  VCC Rot_2B 5.1k
P25  GND GND Key_UP Key_DOWN Key_LEFT Key_RIGHT Key_ESC Key_MENU Keys
* Sheet Name: /OpenAVRc_CoreConnects/
P9  /OpenAVRc_CoreConnects/Miso VCC /OpenAVRc_CoreConnects/Sck /OpenAVRc_CoreConnects/Mosi /OpenAVRc_CoreConnects/Isp_rst GND SPI
C10  /OpenAVRc_CoreConnects/VREF GND 100nF
C18  GND VCC 100nF
C19  GND VCC 100nF
C15  GND VCC 100nF
P1  /OpenAVRc_CoreConnects/Lcd_db0 /OpenAVRc_CoreConnects/Lcd_db1 /OpenAVRc_CoreConnects/Lcd_db2 /OpenAVRc_CoreConnects/Lcd_db3 /OpenAVRc_CoreConnects/Lcd_db4 /OpenAVRc_CoreConnects/Lcd_db5 /OpenAVRc_CoreConnects/Lcd_db6 /OpenAVRc_CoreConnects/Lcd_db7 Trim_RH-> Trim_RH<- Trim_RV-> Trim_RV<- Trim_LV-> Trim_LV<- Trim_LH-> Trim_LH<- Stick_RH Stick_LV Stick_RV Stick_LH Pot_1 Pot_2 Pot_3 U_batt /OpenAVRc_CoreConnects/Microsd_CS /OpenAVRc_CoreConnects/Sck /OpenAVRc_CoreConnects/Mosi /OpenAVRc_CoreConnects/Miso ? PPM16_SIMout Master_PPMout ? Sw_id1 Sw_id2 /OpenAVRc_CoreConnects/Lcd_bla /OpenAVRc_CoreConnects/Lcd_cs /OpenAVRc_CoreConnects/Lcd_rst /OpenAVRc_CoreConnects/Lcd_A0 /OpenAVRc_CoreConnects/Lcd_r/w /OpenAVRc_CoreConnects/Lcd_e Scl Sda BT_Rxd1 BT_Txd1 PPM_in ? ? Sw_ailDR Tele_RX Tele_TX Rot_2push Rot_1A Rot_1B Rot_2B Rot_2A Sw_rudDR Sw_gear Sw_thcut ? ? Rot_1push GND Xmitter_MISO Xmitter_MOSI Xmitter_SCK Audio_Buzzer_out ? Vibreur Sim_Control ? JQ6500Busy JQ6500Data ? CS_CC2500 CS_CYRF6936 CS_NRF24L01 CS_A7105 ? Key_DOWN Key_UP Key_RIGHT Key_LEFT Key_MENU Key_ESC Sw_eleDR Sw_turn ? /OpenAVRc_CoreConnects/Isp_rst VCC /OpenAVRc_CoreConnects/VREF 2560-core
P6  /OpenAVRc_CoreConnects/Microsd_CS /OpenAVRc_CoreConnects/Sck /OpenAVRc_CoreConnects/Mosi /OpenAVRc_CoreConnects/Miso VCC GND Micro_sd
C3  GND VCC 100nF
P16  GND GND LCD_VCC /OpenAVRc_CoreConnects/Lcd_vo Net-_P16-Pad5_ /OpenAVRc_CoreConnects/Lcd_db0 /OpenAVRc_CoreConnects/Lcd_db1 /OpenAVRc_CoreConnects/Lcd_db2 /OpenAVRc_CoreConnects/Lcd_db3 /OpenAVRc_CoreConnects/Lcd_db4 /OpenAVRc_CoreConnects/Lcd_db5 /OpenAVRc_CoreConnects/Lcd_db6 /OpenAVRc_CoreConnects/Lcd_db7 /OpenAVRc_CoreConnects/Lcd_e /OpenAVRc_CoreConnects/Lcd_r/w /OpenAVRc_CoreConnects/Lcd_A0 /OpenAVRc_CoreConnects/Lcd_rst Net-_P16-Pad18_ GND /OpenAVRc_CoreConnects/Lcd_cs LCD
RV6  ? Net-_P16-Pad18_ /OpenAVRc_CoreConnects/Lcd_bla 22K
RV1  GND /OpenAVRc_CoreConnects/Lcd_vo Net-_P16-Pad5_ 220K
P10  Net-_P10-Pad1_ BT_Rxd1 GND Net-_C24-Pad1_ RX1TX1
C24  Net-_C24-Pad1_ GND 100nF
R5  Net-_P10-Pad1_ BT_Txd1 1K
R6  Net-_P10-Pad1_ GND 2,2K
* Sheet Name: /OpenAVRc_HF_Telemetry/
R7  +BATT Net-_R7-Pad2_ 470
P19  +BATT Net-_P19-Pad2_ Net-_P19-Pad2_ Master_PPMout GND VCC /OpenAVRc_HF_Telemetry/TX_module /OpenAVRc_HF_Telemetry/RX_module Module_TX
R8  Net-_P18-Pad1_ Net-_R8-Pad2_ 200
D2  Master_PPMout PPM16_SIMout MBR0520
P18  Net-_P18-Pad1_ GND Ecolage
U3  Net-_R7-Pad2_ GND Tele_RX Net-_P20-Pad5_ TLP290
P20  /OpenAVRc_HF_Telemetry/RX_module /OpenAVRc_HF_Telemetry/TX_module VCC GND Net-_P20-Pad5_ Net-_P20-Pad6_ VCC GND TTL/RS232
U2  Net-_R7-Pad2_ GND Net-_P20-Pad6_ Tele_TX TLP290
U1  PPM_in GND PPM16_SIMout Net-_R8-Pad2_ VCC Sim_Control 74LVC1G3157GV
C6  VCC GND 100nF
P7  CS_CC2500 CS_NRF24L01 CS_CYRF6936 CS_A7105 Xmitter_MISO Xmitter_SCK +3.3V Xmitter_MOSI GND VCC SPIX
* Sheet Name: /OpenAVRc_I2C/
U7  GND GND GND GND Sda Scl GND VCC FM24W256
C22  VCC GND 100nF
U8  Net-_R20-Pad1_ VCC Net-_R15-Pad1_ ? GND GND GND GND GND GND GND GND GND Net-_BT1-Pad1_ Sda Scl DS3231SN
C23  VCC GND 100nF
R15  Net-_R15-Pad1_ VCC 10K
R20  Net-_R20-Pad1_ VCC 10K
BT1  Net-_BT1-Pad1_ GND CR2032
C1  GND VCC 100nF
P15  GND VCC Sda Scl LCD_I2C
P3  GND VCC Sda Scl Option
P2  GND VCC Sda Scl Clock
C2  GND VCC 100nF
R21  Sda VCC 4,7K
R38  Scl VCC 4,7K
* Sheet Name: /OpenAVRc_Audio_Haptic/
C5  GND VCC 100nF
P5  Net-_D1-Pad1_ GND Vibreur
R1  Net-_P8-Pad1_ Audio_Buzzer_out 22K
R2  Net-_P8-Pad2_ /OpenAVRc_Audio_Haptic/JQ_Left_Out 1K
R3  JQ6500Busy Net-_P22-PadBUSY_ 18K
R4  JQ6500Data Net-_P22-PadRX_ 1K
P22  Net-_P22-PadBUSY_ /OpenAVRc_Audio_Haptic/JQ_Left_Out GND Net-_P22-PadRX_ Net-_P22-PadSPK+_ Net-_P22-PadSPK-_ VCC JQ6500_28P
D1  Net-_D1-Pad1_ GND MBR0520
R9  Net-_D1-Pad1_ Vibreur 220
P27  Net-_P22-PadSPK-_ Net-_P22-PadSPK+_ HP
P8  Net-_P8-Pad1_ Net-_P8-Pad2_ VCC GND Audio
R10  /OpenAVRc_Audio_Haptic/JQ_Left_Out GND 22K
C20  VCC GND 100nF
C21  VCC GND 100nF
* Sheet Name: /OpenAVRc_Power/
C31  VCC GND 100nF
R16  U_batt GND 2.7K
P26  VCC LCD_VCC +3.3V LCD_Alim
C38  +3.3V GND 100nF
P21  /OpenAVRc_Power/LIPO+ +BATT Sw_power
U5  GND +3.3V VCC +3.3V LD1117S33TR
U4  /OpenAVRc_Power/DCDC_IN+ GND VCC L4941
R17  U_batt +BATT 5.1K
C28  /OpenAVRc_Power/DCDC_IN+ GND 100µF
D6  /OpenAVRc_Power/DCDC_IN+ +BATT MBR0520
C7  VCC GND 100µF
C8  +3.3V GND 47µF
P30  GND GND /OpenAVRc_Power/DCDC_IN+ /OpenAVRc_Power/DCDC_IN+ VCC VCC GND GND MiniDCDC3A
P17  GND /OpenAVRc_Power/LIPO+ BATT
D3  U_batt VCC LL4148
D4  GND U_batt LL4148

.end
